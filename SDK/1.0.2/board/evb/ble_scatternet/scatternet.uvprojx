# Keil uVision project scatternet.uvprojx, settings and files
target scatternet (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\mcu\module\data_uart_cmd;..\..\..\src\sample\ble_scatternet;..\ble_scatternet
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_rcc.c rtl876x_uart.c
  group profile
    ../../../src/ble/profile/client/: simple_ble_client.c gaps_client.c bas_client.c
    ../../../src/ble/profile/server/: simple_ble_service.c bas.c
  group app
    ../../../src/sample/ble_scatternet/: main.c app_task.c link_mgr.c scatternet_app.c user_cmd.c
    ../../../src/mcu/module/data_uart_cmd/: data_uart.c user_cmd_parse.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
