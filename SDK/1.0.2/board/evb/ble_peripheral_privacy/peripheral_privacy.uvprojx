# Keil uVision project peripheral_privacy.uvprojx, settings and files
target ble_peripheral_privacy (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\mcu\module\data_uart_cmd;..\..\..\src\ble\privacy;..\..\..\src\sample\ble_peripheral_privacy;..\ble_peripheral_privacy
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_rcc.c rtl876x_uart.c rtl876x_io_dlps.c
  group profile
    ../../../src/ble/profile/server/: simple_ble_service.c bas.c
  group app
    ../../../src/ble/privacy/: privacy_mgnt.c
    ../../../src/sample/ble_peripheral_privacy/: app_task.c main.c peripheral_privacy_app.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
  group user_cmd
    ../../../src/mcu/module/data_uart_cmd/: data_uart.c data_uart_dlps.c user_cmd_parse.c
    ../../../src/sample/ble_peripheral_privacy/: user_cmd.c
