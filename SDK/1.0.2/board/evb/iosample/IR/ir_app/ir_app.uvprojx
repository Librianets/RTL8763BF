# Keil uVision project ir_app.uvprojx, settings and files
target ir_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\..\..\inc\bluetooth\gap;..\..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\..\inc\bluetooth\profile;..\..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\..\inc\os;..\..\..\..\..\inc\platform;..\..\..\..\..\inc\platform\cmsis;..\..\..\..\..\src\sample\peripheral\IR\ir_app;..\..\..\..\..\src\sample\peripheral\IR\ir_learn;..\..\..\..\..\src\sample\peripheral\IR\ir_lib\app;..\..\..\..\..\src\sample\peripheral\IR\ir_lib\config;..\..\..\..\..\src\sample\peripheral\IR\ir_lib\encode;..\..\..\..\..\src\sample\peripheral\IR\ir_lib\module;..\..\..\..\..\src\sample\peripheral\IR\ir_lib\protocol\inc;..\..\..\..\..\src\sample\peripheral\IR\led;..\..\..\..\..\src\sample\peripheral\IR\ir_app;..\..\..\..\..\inc\peripheral;..\..\..\..\..\inc\app;..\ir_app
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../../bin/: ROM.lib gap_utils.lib
  group cmsis
    ../../../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../../../src/mcu/rtl876x/: system_rtl8762c.c
  group profile
    ../../../../../src/ble/profile/server/: simple_ble_service.c bas.c
  group peripheral
    ../../../../../src/mcu/peripheral/: rtl876x_gpio.c rtl876x_ir.c rtl876x_rcc.c rtl876x_tim.c
  group app
    ../../../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../../../src/sample/peripheral/IR/ir_app/: app_task.c ir_app.c main.c
  group ir_send
    ../../../../../src/sample/peripheral/IR/ir_lib/app/: ir_send_app.c
    ../../../../../src/sample/peripheral/IR/ir_lib/module/: ir_trans.c
  group ir_prot
    ../../../../../src/sample/peripheral/IR/ir_lib/encode/: ir_encode.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/6124/: sony6124_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/dvb/: dvb_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/konica/: konica_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/lc7464m/: lc7464m_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/mitc8d8/: mitc8d8_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/nec/: nec_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/pioneer/: pioneer_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/raw_pack/: raw_pack_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/rc5/: rc5_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/sharp/: sharp_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/tc9012/: tc9012_prot.c
    ../../../../../src/sample/peripheral/IR/ir_lib/protocol/src/victorc8d8/: victorc8d8_prot.c
  group ir_learn
    ../../../../../src/sample/peripheral/IR/ir_learn/: data_trans.c ir_learn.c ir_learn_app.c
  group led
    ../../../../../src/sample/peripheral/IR/led/: ir_led.c
