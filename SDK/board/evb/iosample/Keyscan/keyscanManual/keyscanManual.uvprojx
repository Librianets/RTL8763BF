# Keil uVision project keyscanManual.uvprojx, settings and files
target keyscanManual (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\..\..\inc\peripheral;..\..\..\..\..\inc\platform;..\..\..\..\..\inc\platform\cmsis;..\..\..\..\..\inc\os;..\..\..\..\..\src\sample\peripheral\Keyscan\manualmode;..\keyscanManual;..\..\..\..\..\inc\app;..\..\..\..\..\inc\bluetooth\gap
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../../bin/: ROM.lib gap_utils.lib
  group cmsis
    ../../../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../../../src/mcu/peripheral/: rtl876x_rcc.c rtl876x_gpio.c rtl876x_keyscan.c
  group app
    ../../../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../../../src/sample/peripheral/Keyscan/manualmode/: main.c keyscan_app.c app_task.c
