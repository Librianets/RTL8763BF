# Keil uVision project rtl8763bf.uvprojx, settings and files
target scatternet (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\inc\os;..\..\..\src\app\pxp;..\pxp;..\..\..\src\ble\profile\server;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\app;..\..\..\inc\peripheral;..\..\..\inc\os;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile\server
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../include/SDK/inc/platform/: rom_uuid.h app_define.h
  group lib
    ../include/SDK/bin/: ROM.lib gap_utils.lib
  group cmsis
    ../include/SDK/src/mcu/rtl876x/: system_rtl8762c.c
    ../include/SDK/src/app/pxp/: app_task.c iohandle.c main.c
  group peripheral
    ../include/SDK/src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_rcc.c
  group profile
    ../include/SDK/src/ble/profile/server/: ias.c lls.c tps.c bas.c dis.c
    ../include/SDK/src/app/pxp/: kns.c
  group app
    ../include/SDK/src/app/pxp/: pxp_app.c
    ../include/SDK/src/mcu/rtl876x/: overlay_mgr.c
    ../include/SDK/src/mcu/rtl876x/arm/: startup_rtl8762c.s
target RTL8786BF (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: rtp8763_demo +hex
  BeforeMake: ..\include\SDK\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\include\SDK\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\include\SDK\inc\app;..\include\SDK\inc\platform;..\include\SDK\inc\platform\cmsis;..\include\SDK\inc\os;..\include\SDK\src\app\pxp;..\include\SDK\src\ble\profile\server;..\include\SDK\inc\bluetooth\profile\server;..\include\SDK\inc\app;..\include\SDK\inc\peripheral;..\include\SDK\inc\os;..\include\SDK\inc\bluetooth\profile;..\include\SDK\inc\bluetooth\gap;..\keilproject;..\include\SDK\inc\bluetooth\gap\gap_lib;..\include\SDK\inc\bluetooth\profile\server;..\source;..\lib;..\include
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl8763bf.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
