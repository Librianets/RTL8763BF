# Keil uVision project pxp.uvprojx, settings and files
target scatternet (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\SDK\inc\app;..\SDK\inc\platform;..\SDK\inc\platform\cmsis;..\SDK\inc\os;..\SDK\src\app\pxp;..\SDK\src\ble\profile\server;..\SDK\inc\bluetooth\profile\server;..\SDK\inc\app;..\SDK\inc\peripheral;..\SDK\inc\os;..\SDK\inc\bluetooth\profile;..\SDK\bluetooth\gap;..\SDK\bluetooth\gap\gap_lib;..\SDK\bluetooth\profile\server
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../SDK/inc/platform/: rom_uuid.h app_define.h
  group lib
    ../SDK/bin/: ROM.lib gap_utils.lib
  group cmsis
    ../SDK/src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../SDK/src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../SDK/src/mcu/peripheral/: rtl876x_io_dlps.c
    ../../../src/mcu/peripheral/: rtl876x_rcc.c
  group profile
    ../../../src/ble/profile/server/: ias.c lls.c tps.c bas.c dis.c
    ../../../src/app/pxp/: kns.c
  group app
    ../../../src/app/pxp/: app_task.c iohandle.c main.c pxp_app.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
