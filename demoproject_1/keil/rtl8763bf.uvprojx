# Keil uVision project rtl8763bf.uvprojx, settings and files
target RTL8786BF (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtp8763_demo +hex
  BeforeMake: before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\;.\;..\include;..\include\SDK;..\include\SDK\bluetooth;..\include\SDK\app;..\include\SDK\os;..\include\SDK\peripheral;..\include\SDK\platform;..\include\SDK\bluetooth\gap;..\include\SDK\bluetooth\profile;..\include\SDK\bluetooth\gap\gap_lib;..\include\SDK\bluetooth\profile\client;..\include\SDK\bluetooth\profile\server;..\include\SDK\os\system_trace;..\include\SDK\platform\cmsis;..\keil
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\include\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../include/: rom_uuid.h app_define.h
  group lib
    ../lib/: ROM.lib gap_utils.lib
  group cmsis
    ../source/cmsis/: system_rtl8762c.c app_task.c iohandle.c
  group peripheral
    ../source/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_rcc.c
  group profile
    ../source/profile/: ias.c lls.c tps.c bas.c kns.c dis.c
  group app
    ../source/cmsis/: main.c
    ../source/app/: pxp_app.c overlay_mgr.c startup_rtl8762c.s
